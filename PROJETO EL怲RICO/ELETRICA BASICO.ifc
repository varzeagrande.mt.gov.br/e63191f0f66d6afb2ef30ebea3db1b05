Properties of the parts of a building model (IFC4)

# File
Description: IFC4
Time: 2019-07-24T18:32:35
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
TERREO | TERREO | 0
COBERTURA | COBERTURA | 300

# IfcCableCarrierSegment: Eletroduto tipo leve (374)
Type - PredefinedType: CONDUITSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 100
Pset_Identificação_Elemento - Rede: Elétrica; Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo leve; Aplicação: Circular
Name | In | Diâmetro | Comprimento | Nome
El10 | TERREO | ø1" | 280 | 1"
El100 | TERREO | ø3/4" | 425 | 3/4"
El101 | TERREO | ø3/4" | 120 | 3/4"
El102 | TERREO | ø3/4" | 40 | 3/4"
El103 | TERREO | ø3/4" | 140 | 3/4"
El104 | TERREO | ø3/4" | 130 | 3/4"
El105 | TERREO | ø3/4" | 30 | 3/4"
El106 | TERREO | ø3/4" | 200 | 3/4"
El107 | TERREO | ø3/4" | 260 | 3/4"
El108 | TERREO | ø3/4" | 295 | 3/4"
El109 | TERREO | ø3/4" | 375 | 3/4"
El11 | TERREO | ø3/4" | 365 | 3/4"
El110 | TERREO | ø3/4" | 505 | 3/4"
El111 | TERREO | ø3/4" | 345 | 3/4"
El112 | TERREO | ø3/4" | 335 | 3/4"
El113 | TERREO | ø3/4" | 30 | 3/4"
El114 | TERREO | ø3/4" | 150 | 3/4"
El115 | TERREO | ø3/4" | 200 | 3/4"
El116 | TERREO | ø3/4" | 260 | 3/4"
El117 | TERREO | ø3/4" | 335 | 3/4"
El118 | TERREO | ø3/4" | 415 | 3/4"
El119 | TERREO | ø3/4" | 345 | 3/4"
El12 | TERREO | ø3/4" | 405 | 3/4"
El120 | TERREO | ø3/4" | 295 | 3/4"
El121 | TERREO | ø3/4" | 375 | 3/4"
El122 | TERREO | ø3/4" | 140 | 3/4"
El123 | TERREO | ø3/4" | 90 | 3/4"
El124 | TERREO | ø3/4" | 150 | 3/4"
El125 | TERREO | ø3/4" | 20 | 3/4"
El126 | TERREO | ø3/4" | 170 | 3/4"
El127 | TERREO | ø3/4" | 170 | 3/4"
El128 | TERREO | ø3/4" | 275 | 3/4"
El129 | TERREO | ø3/4" | 425 | 3/4"
El13 | TERREO | ø3/4" | 395 | 3/4"
El131 | TERREO | ø3/4" | 415 | 3/4"
El132 | TERREO | ø3/4" | 445 | 3/4"
El133 | TERREO | ø3/4" | 140 | 3/4"
El134 | TERREO | ø3/4" | 40 | 3/4"
El135 | TERREO | ø3/4" | 140 | 3/4"
El136 | TERREO | ø3/4" | 170 | 3/4"
El137 | TERREO | ø3/4" | 170 | 3/4"
El138 | TERREO | ø3/4" | 275 | 3/4"
El139 | TERREO | ø3/4" | 425 | 3/4"
El14 | TERREO | ø3/4" | 305 | 3/4"
El140 | TERREO | ø3/4" | 325 | 3/4"
El141 | TERREO | ø3/4" | 425 | 3/4"
El142 | TERREO | ø3/4" | 140 | 3/4"
El143 | TERREO | ø3/4" | 40 | 3/4"
El144 | TERREO | ø3/4" | 50 | 3/4"
El145 | TERREO | ø3/4" | 20 | 3/4"
El146 | TERREO | ø3/4" | 170 | 3/4"
El147 | TERREO | ø3/4" | 170 | 3/4"
El148 | TERREO | ø3/4" | 275 | 3/4"
El149 | TERREO | ø3/4" | 325 | 3/4"
El15 | TERREO | ø3/4" | 130 | 3/4"
El150 | TERREO | ø3/4" | 425 | 3/4"
El151 | TERREO | ø3/4" | 130 | 3/4"
El152 | TERREO | ø3/4" | 30 | 3/4"
El153 | TERREO | ø3/4" | 50 | 3/4"
El154 | TERREO | ø3/4" | 30 | 3/4"
El155 | TERREO | ø3/4" | 425 | 3/4"
El156 | TERREO | ø3/4" | 220 | 3/4"
El157 | TERREO | ø3/4" | 335 | 3/4"
El158 | TERREO | ø3/4" | 335 | 3/4"
El159 | TERREO | ø3/4" | 220 | 3/4"
El16 | TERREO | ø3/4" | 40 | 3/4"
El160 | TERREO | ø3/4" | 230 | 3/4"
El161 | TERREO | ø3/4" | 260 | 3/4"
El162 | TERREO | ø3/4" | 295 | 3/4"
El163 | TERREO | ø3/4" | 285 | 3/4"
El164 | TERREO | ø3/4" | 285 | 3/4"
El165 | TERREO | ø3/4" | 230 | 3/4"
El166 | TERREO | ø3/4" | 295 | 3/4"
El167 | TERREO | ø3/4" | 260 | 3/4"
El168 | TERREO | ø3/4" | 290 | 3/4"
El169 | TERREO | ø3/4" | 250 | 3/4"
El17 | TERREO | ø3/4" | 210 | 3/4"
El170 | TERREO | ø3/4" | 290 | 3/4"
El171 | TERREO | ø3/4" | 305 | 3/4"
El172 | TERREO | ø3/4" | 465 | 3/4"
El173 | TERREO | ø3/4" | 485 | 3/4"
El174 | TERREO | ø3/4" | 395 | 3/4"
El175 | TERREO | ø3/4" | 415 | 3/4"
El176 | TERREO | ø3/4" | 240 | 3/4"
El177 | TERREO | ø3/4" | 200 | 3/4"
El178 | TERREO | ø3/4" | 230 | 3/4"
El179 | TERREO | ø3/4" | 140 | 3/4"
El18 | TERREO | ø3/4" | 160 | 3/4"
El180 | TERREO | ø3/4" | 130 | 3/4"
El181 | TERREO | ø3/4" | 130 | 3/4"
El182 | TERREO | ø1" | 235 | 1"
El183 | TERREO | ø1" | 235 | 1"
El184 | TERREO | ø3/4" | 265 | 3/4"
El185 | TERREO | ø3/4" | 265 | 3/4"
El186 | TERREO | ø3/4" | 295 | 3/4"
El187 | TERREO | ø3/4" | 295 | 3/4"
El188 | TERREO | ø3/4" | 275 | 3/4"
El189 | TERREO | ø3/4" | 285 | 3/4"
El19 | TERREO | ø3/4" | 150 | 3/4"
El190 | TERREO | ø1" | 220 | 1"
El191 | TERREO | ø1" | 160 | 1"
El192 | TERREO | ø3/4" | 220 | 3/4"
El193 | TERREO | ø1" | 160 | 1"
El194 | TERREO | ø1" | 220 | 1"
El196 | TERREO | ø3/4" | 220 | 3/4"
El197 | TERREO | ø1" | 230 | 1"
El198 | TERREO | ø3/4" | 230 | 3/4"
El199 | TERREO | ø1" | 190 | 1"
El2 | TERREO | ø1" | 285 | 1"
El20 | TERREO | ø3/4" | 150 | 3/4"
El200 | TERREO | ø1" | 180 | 1"
El201 | TERREO | ø3/4" | 365 | 3/4"
El202 | TERREO | ø3/4" | 325 | 3/4"
El203 | TERREO | ø3/4" | 335 | 3/4"
El204 | TERREO | ø3/4" | 385 | 3/4"
El205 | TERREO | ø3/4" | 160 | 3/4"
El206 | TERREO | ø3/4" | 190 | 3/4"
El207 | TERREO | ø3/4" | 275 | 3/4"
El208 | TERREO | ø3/4" | 275 | 3/4"
El209 | TERREO | ø3/4" | 150 | 3/4"
El21 | TERREO | ø3/4" | 180 | 3/4"
El210 | TERREO | ø3/4" | 425 | 3/4"
El211 | TERREO | ø3/4" | 325 | 3/4"
El212 | TERREO | ø3/4" | 415 | 3/4"
El214 | TERREO | ø3/4" | 170 | 3/4"
El215 | TERREO | ø3/4" | 170 | 3/4"
El216 | TERREO | ø3/4" | 265 | 3/4"
El217 | TERREO | ø3/4" | 140 | 3/4"
El218 | TERREO | ø3/4" | 130 | 3/4"
El219 | TERREO | ø3/4" | 150 | 3/4"
El22 | TERREO | ø3/4" | 20 | 3/4"
El220 | TERREO | ø3/4" | 170 | 3/4"
El221 | TERREO | ø3/4" | 210 | 3/4"
El222 | TERREO | ø3/4" | 140 | 3/4"
El223 | TERREO | ø3/4" | 170 | 3/4"
El224 | TERREO | ø3/4" | 170 | 3/4"
El225 | TERREO | ø3/4" | 180 | 3/4"
El226 | TERREO | ø3/4" | 180 | 3/4"
El227 | TERREO | ø3/4" | 275 | 3/4"
El228 | TERREO | ø3/4" | 275 | 3/4"
El229 | TERREO | ø3/4" | 265 | 3/4"
El23 | TERREO | ø3/4" | 130 | 3/4"
El230 | TERREO | ø3/4" | 315 | 3/4"
El231 | TERREO | ø3/4" | 315 | 3/4"
El232 | TERREO | ø3/4" | 375 | 3/4"
El233 | TERREO | ø3/4" | 385 | 3/4"
El234 | TERREO | ø3/4" | 295 | 3/4"
El235 | TERREO | ø3/4" | 365 | 3/4"
El236 | TERREO | ø3/4" | 275 | 3/4"
El237 | TERREO | ø3/4" | 485 | 3/4"
El24 | TERREO | ø3/4" | 170 | 3/4"
El240 | TERREO | ø3/4" | 370 | 3/4"
El248 | TERREO | ø1" | 220 | 1"
El249 | TERREO | ø1" | 200 | 1"
El25 | TERREO | ø3/4" | 170 | 3/4"
El250 | TERREO | ø3/4" | 240 | 3/4"
El251 | TERREO | ø3/4" | 405 | 3/4"
El252 | TERREO | ø3/4" | 315 | 3/4"
El253 | TERREO | ø3/4" | 80 | 3/4"
El254 | TERREO | ø3/4" | 160 | 3/4"
El255 | TERREO | ø3/4" | 330 | 3/4"
El256 | TERREO | ø3/4" | 240 | 3/4"
El257 | TERREO | ø3/4" | 250 | 3/4"
El258 | TERREO | ø3/4" | 130 | 3/4"
El259 | TERREO | ø3/4" | 130 | 3/4"
El26 | TERREO | ø3/4" | 275 | 3/4"
El260 | TERREO | ø3/4" | 190 | 3/4"
El261 | TERREO | ø3/4" | 300 | 3/4"
El262 | TERREO | ø3/4" | 435 | 3/4"
El264 | TERREO | ø3/4" | 150 | 3/4"
El265 | TERREO | ø3/4" | 270 | 3/4"
El266 | TERREO | ø3/4" | 300 | 3/4"
El267 | TERREO | ø3/4" | 370 | 3/4"
El268 | TERREO | ø1" | 170 | 1"
El269 | TERREO | ø3/4" | 380 | 3/4"
El27 | TERREO | ø3/4" | 435 | 3/4"
El270 | TERREO | ø1" | 170 | 1"
El271 | TERREO | ø3/4" | 370 | 3/4"
El272 | TERREO | ø3/4" | 220 | 3/4"
El275 | TERREO | ø3/4" | 210 | 3/4"
El276 | TERREO | ø3/4" | 180 | 3/4"
El277 | TERREO | ø3/4" | 290 | 3/4"
El278 | TERREO | ø3/4" | 415 | 3/4"
El279 | TERREO | ø3/4" | 190 | 3/4"
El28 | TERREO | ø3/4" | 415 | 3/4"
El286 | TERREO | ø1" | 310 | 1"
El287 | TERREO | ø3/4" | 180 | 3/4"
El288 | TERREO | ø3/4" | 230 | 3/4"
El289 | TERREO | ø3/4" | 390 | 3/4"
El29 | TERREO | ø3/4" | 325 | 3/4"
El290 | TERREO | ø3/4" | 390 | 3/4"
El291 | TERREO | ø3/4" | 210 | 3/4"
El292 | TERREO | ø3/4" | 200 | 3/4"
El293 | TERREO | ø3/4" | 280 | 3/4"
El294 | TERREO | ø3/4" | 200 | 3/4"
El295 | TERREO | ø3/4" | 210 | 3/4"
El296 | TERREO | ø3/4" | 280 | 3/4"
El297 | TERREO | ø3/4" | 190 | 3/4"
El298 | TERREO | ø3/4" | 210 | 3/4"
El299 | TERREO | ø3/4" | 270 | 3/4"
El3 | TERREO | ø3/4" | 295 | 3/4"
El30 | TERREO | ø3/4" | 170 | 3/4"
El300 | TERREO | ø3/4" | 210 | 3/4"
El301 | TERREO | ø3/4" | 200 | 3/4"
El302 | TERREO | ø3/4" | 200 | 3/4"
El303 | TERREO | ø3/4" | 240 | 3/4"
El304 | TERREO | ø3/4" | 210 | 3/4"
El305 | TERREO | ø3/4" | 200 | 3/4"
El31 | TERREO | ø3/4" | 170 | 3/4"
El310 | TERREO | ø3/4" | 270 | 3/4"
El312 | TERREO | ø3/4" | 300 | 3/4"
El313 | TERREO | ø3/4" | 270 | 3/4"
El314 | TERREO | ø1" | 280 | 1"
El315 | TERREO | ø3/4" | 390 | 3/4"
El316 | TERREO | ø3/4" | 270 | 3/4"
El317 | TERREO | ø3/4" | 190 | 3/4"
El318 | TERREO | ø3/4" | 240 | 3/4"
El319 | TERREO | ø3/4" | 300 | 3/4"
El32 | TERREO | ø3/4" | 275 | 3/4"
El320 | TERREO | ø3/4" | 355 | 3/4"
El321 | TERREO | ø3/4" | 315 | 3/4"
El322 | TERREO | ø3/4" | 305 | 3/4"
El324 | TERREO | ø3/4" | 360 | 3/4"
El325 | TERREO | ø3/4" | 360 | 3/4"
El326 | TERREO | ø3/4" | 360 | 3/4"
El327 | TERREO | ø3/4" | 330 | 3/4"
El328 | TERREO | ø3/4" | 330 | 3/4"
El329 | TERREO | ø3/4" | 390 | 3/4"
El33 | TERREO | ø3/4" | 425 | 3/4"
El330 | TERREO | ø3/4" | 350 | 3/4"
El331 | TERREO | ø3/4" | 260 | 3/4"
El332 | TERREO | ø3/4" | 260 | 3/4"
El334 | TERREO | ø3/4" | 280 | 3/4"
El335 | TERREO | ø3/4" | 350 | 3/4"
El336 | TERREO | ø3/4" | 325 | 3/4"
El337 | TERREO | ø3/4" | 530 | 3/4"
El338 | TERREO | ø3/4" | 480 | 3/4"
El339 | TERREO | ø3/4" | 520 | 3/4"
El34 | TERREO | ø3/4" | 415 | 3/4"
El340 | TERREO | ø3/4" | 420 | 3/4"
El342 | TERREO | ø3/4" | 130 | 3/4"
El343 | TERREO | ø3/4" | 140 | 3/4"
El344 | TERREO | ø3/4" | 445 | 3/4"
El345 | TERREO | ø3/4" | 445 | 3/4"
El347 | TERREO | ø3/4" | 445 | 3/4"
El348 | TERREO | ø3/4" | 140 | 3/4"
El349 | TERREO | ø3/4" | 120 | 3/4"
El35 | TERREO | ø3/4" | 325 | 3/4"
El350 | TERREO | ø3/4" | 445 | 3/4"
El351 | TERREO | ø3/4" | 230 | 3/4"
El352 | TERREO | ø3/4" | 375 | 3/4"
El353 | TERREO | ø3/4" | 180 | 3/4"
El354 | TERREO | ø3/4" | 300 | 3/4"
El36 | TERREO | ø3/4" | 160 | 3/4"
El364 | TERREO | ø3/4" | 445 | 3/4"
El365 | TERREO | ø3/4" | 90 | 3/4"
El366 | TERREO | ø3/4" | 880 | 3/4"
El367 | TERREO | ø3/4" | 480 | 3/4"
El368 | TERREO | ø3/4" | 190 | 3/4"
El369 | TERREO | ø3/4" | 30 | 3/4"
El37 | TERREO | ø3/4" | 120 | 3/4"
El370 | TERREO | ø3/4" | 260 | 3/4"
El371 | TERREO | ø3/4" | 190 | 3/4"
El372 | TERREO | ø3/4" | 375 | 3/4"
El373 | TERREO | ø3/4" | 140 | 3/4"
El374 | TERREO | ø3/4" | 140 | 3/4"
El375 | TERREO | ø3/4" | 170 | 3/4"
El377 | TERREO | ø3/4" | 480 | 3/4"
El378 | TERREO | ø3/4" | 330 | 3/4"
El379 | TERREO | ø3/4" | 180 | 3/4"
El38 | TERREO | ø3/4" | 30 | 3/4"
El380 | TERREO | ø3/4" | 300 | 3/4"
El382 | TERREO | ø3/4" | 210 | 3/4"
El383 | TERREO | ø3/4" | 310 | 3/4"
El384 | TERREO | ø3/4" | 260 | 3/4"
El385 | TERREO | ø3/4" | 470 | 3/4"
El386 | TERREO | ø3/4" | 580 | 3/4"
El387 | TERREO | ø3/4" | 540 | 3/4"
El388 | TERREO | ø3/4" | 690 | 3/4"
El389 | TERREO | ø3/4" | 40 | 3/4"
El39 | TERREO | ø3/4" | 170 | 3/4"
El390 | TERREO | ø3/4" | 315 | 3/4"
El391 | TERREO | ø3/4" | 740 | 3/4"
El392 | TERREO | ø3/4" | 100 | 3/4"
El393 | TERREO | ø3/4" | 390 | 3/4"
El394 | TERREO | ø3/4" | 20 | 3/4"
El395 | TERREO | ø3/4" | 230 | 3/4"
El396 | TERREO | ø3/4" | 415 | 3/4"
El4 | TERREO | ø3/4" | 275 | 3/4"
El40 | TERREO | ø3/4" | 240 | 3/4"
El400 | TERREO | ø3/4" | 20 | 3/4"
El403 | TERREO | ø3/4" | 160 | 3/4"
El405 | TERREO | ø3/4" | 535 | 3/4"
El41 | TERREO | ø3/4" | 170 | 3/4"
El42 | TERREO | ø3/4" | 240 | 3/4"
El44 | TERREO | ø3/4" | 365 | 3/4"
El45 | TERREO | ø3/4" | 395 | 3/4"
El46 | TERREO | ø3/4" | 425 | 3/4"
El47 | TERREO | ø3/4" | 295 | 3/4"
El49 | TERREO | ø3/4" | 220 | 3/4"
El5 | TERREO | ø3/4" | 305 | 3/4"
El50 | TERREO | ø3/4" | 310 | 3/4"
El51 | TERREO | ø3/4" | 230 | 3/4"
El52 | TERREO | ø3/4" | 220 | 3/4"
El53 | TERREO | ø3/4" | 270 | 3/4"
El54 | TERREO | ø3/4" | 220 | 3/4"
El55 | TERREO | ø3/4" | 250 | 3/4"
El56 | TERREO | ø3/4" | 180 | 3/4"
El57 | TERREO | ø3/4" | 250 | 3/4"
El58 | TERREO | ø3/4" | 180 | 3/4"
El59 | TERREO | ø3/4" | 275 | 3/4"
El6 | TERREO | ø3/4" | 210 | 3/4"
El60 | TERREO | ø3/4" | 275 | 3/4"
El61 | TERREO | ø3/4" | 305 | 3/4"
El62 | TERREO | ø3/4" | 120 | 3/4"
El63 | TERREO | ø3/4" | 140 | 3/4"
El64 | TERREO | ø3/4" | 100 | 3/4"
El66 | TERREO | ø3/4" | 180 | 3/4"
El67 | TERREO | ø3/4" | 250 | 3/4"
El68 | TERREO | ø3/4" | 260 | 3/4"
El69 | TERREO | ø3/4" | 250 | 3/4"
El7 | TERREO | ø3/4" | 170 | 3/4"
El70 | TERREO | ø3/4" | 305 | 3/4"
El71 | TERREO | ø3/4" | 445 | 3/4"
El72 | TERREO | ø3/4" | 405 | 3/4"
El73 | TERREO | ø3/4" | 315 | 3/4"
El74 | TERREO | ø3/4" | 455 | 3/4"
El75 | TERREO | ø3/4" | 120 | 3/4"
El76 | TERREO | ø3/4" | 240 | 3/4"
El77 | TERREO | ø3/4" | 30 | 3/4"
El78 | TERREO | ø3/4" | 130 | 3/4"
El79 | TERREO | ø3/4" | 40 | 3/4"
El8 | TERREO | ø3/4" | 250 | 3/4"
El80 | TERREO | ø3/4" | 110 | 3/4"
El81 | TERREO | ø3/4" | 290 | 3/4"
El82 | TERREO | ø3/4" | 250 | 3/4"
El83 | TERREO | ø3/4" | 290 | 3/4"
El84 | TERREO | ø3/4" | 250 | 3/4"
El85 | TERREO | ø3/4" | 305 | 3/4"
El86 | TERREO | ø3/4" | 485 | 3/4"
El87 | TERREO | ø3/4" | 475 | 3/4"
El88 | TERREO | ø3/4" | 325 | 3/4"
El89 | TERREO | ø3/4" | 415 | 3/4"
El9 | TERREO | ø3/4" | 170 | 3/4"
El90 | TERREO | ø3/4" | 190 | 3/4"
El91 | TERREO | ø3/4" | 260 | 3/4"
El92 | TERREO | ø3/4" | 50 | 3/4"
El93 | TERREO | ø3/4" | 120 | 3/4"
El94 | TERREO | ø3/4" | 140 | 3/4"
El95 | TERREO | ø3/4" | 170 | 3/4"
El96 | TERREO | ø3/4" | 170 | 3/4"
El97 | TERREO | ø3/4" | 275 | 3/4"
El98 | TERREO | ø3/4" | 415 | 3/4"
El99 | TERREO | ø3/4" | 325 | 3/4"
El10 | COBERTURA | ø3/4" | 140 | 3/4"
El11 | COBERTURA | ø3/4" | 140 | 3/4"
El12 | COBERTURA | ø3/4" | 140 | 3/4"
El13 | COBERTURA | ø3/4" | 140 | 3/4"
El14 | COBERTURA | ø3/4" | 140 | 3/4"
El15 | COBERTURA | ø3/4" | 140 | 3/4"
El16 | COBERTURA | ø3/4" | 140 | 3/4"
El18 | COBERTURA | ø3/4" | 140 | 3/4"
El19 | COBERTURA | ø3/4" | 140 | 3/4"
El20 | COBERTURA | ø3/4" | 140 | 3/4"
El21 | COBERTURA | ø3/4" | 210 | 3/4"
El22 | COBERTURA | ø3/4" | 190 | 3/4"
El27 | COBERTURA | ø3/4" | 1330 | 3/4"
El28 | COBERTURA | ø3/4" | 670 | 3/4"
El29 | COBERTURA | ø3/4" | 380 | 3/4"
El4 | COBERTURA | ø3/4" | 140 | 3/4"
El5 | COBERTURA | ø3/4" | 140 | 3/4"
El6 | COBERTURA | ø3/4" | 140 | 3/4"
El7 | COBERTURA | ø3/4" | 140 | 3/4"
El8 | COBERTURA | ø3/4" | 140 | 3/4"

# IfcCableCarrierSegment: Eletroduto tipo pesado (25)
Type - PredefinedType: CONDUITSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 100
Pset_Identificação_Elemento - Rede: Elétrica; Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado; Aplicação: Circular
Name | In | Diâmetro | Comprimento | Nome
El263 | TERREO | ø1 1/2" | 150 | 1.1/2"
El273 | TERREO | ø1 1/2" | 385 | 1.1/2"
El281 | TERREO | ø3" | 400 | 3"
El281 | TERREO | ø1 1/2" | 380 | 1.1/2"
El282 | TERREO | ø3" | 380 | 3"
El283 | TERREO | ø3" | 340 | 3"
El284 | TERREO | ø1 1/2" | 430 | 1.1/2"
El285 | TERREO | ø1 1/2" | 420 | 1.1/2"
El355 | TERREO | ø3" | 425 | 3"
El356 | TERREO | ø3" | 1180 | 3"
El357 | TERREO | ø4" | 1820 | 4"
El358 | TERREO | ø3" | 870 | 3"
El359 | TERREO | ø3" | 190 | 3"
El360 | TERREO | ø3" | 290 | 3"
El361 | TERREO | ø3" | 50 | 3"
El362 | TERREO | ø3" | 240 | 3"
El376 | TERREO | ø3" | 190 | 3"
El397 | TERREO | ø3" | 140 | 3"
El398 | TERREO | ø3" | 60 | 3"
El399 | TERREO | ø2" | 445 | 2"
El402 | TERREO | ø2" | 150 | 2"
El404 | TERREO | ø2" | 485 | 2"
El24 | COBERTURA | ø2" | 200 | 2"
El25 | COBERTURA | ø2" | 260 | 2"
El26 | COBERTURA | ø2" | 140 | 2"

# IfcElectricDistributionBoard: Caixa de barramentos (4)
Type - PredefinedType: DISTRIBUTIONBOARD
Pset_Identificação_Elemento - Rede: Elétrica; Nome: Caixa de barramentos; Descrição: Caixa de medição instalada a 1,50m do piso; Aplicação: Quadro de distribuição; Classe: Quadro de proteção - COELBA; Tipo: Caixa de barramentos
Pset_ElectricalDeviceCommon-Ponto1 - NumberOfPoles: 3
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Disjuntor
Name | In | Pset_ElectricalDeviceCommon-Ponto1, NominalCurrent | Pset_ElectricalDeviceCommon-Ponto2, NominalCurrent | NumberOfPoles | Pset_ElectricalDeviceCommon-Ponto2, sets with these values = Pset_AltoQi_QiBuilder-Ponto2, sets with these values | Tipo de ponto
QD1 | TERREO | 125.000000 | 125.000000 | 3 | 2 | Disjuntor
QD2 | TERREO | 40.000000 | 40.000000 | 3 | 2 | Disjuntor
QD3 | TERREO | 50.000000 | 50.000000 | 3 | 2 | Disjuntor
QD1 | COBERTURA | 90.000000

# IfcElectricDistributionBoard: Edifício de uso coletivo, QM1
In: TERREO
Type - PredefinedType: CONSUMERUNIT
Pset_Identificação_Elemento - Rede: Elétrica; Nome: Medição agrupada até 12 medidores; Descrição: Caixa de medição embutir a 1,50m do piso; Aplicação: Quadro de medição; Classe: Quadro de medição - AMPLA; Tipo: Edifício de uso coletivo
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 125.000000; NumberOfPoles: 3
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Disjuntor

# IfcFlowMeter: Ancoragem em pontalete - Medição trifásica em parede - Demanda de 10 à 24KVA, AL1
In: TERREO
Type - PredefinedType: ENERGYMETER
Pset_AltoQi_QiBuilder - Tensão: 220/127 V
Pset_Identificação_Elemento - Rede: Elétrica; Nome: Demanda de 10 à 15KVA; Descrição: Entrada de serviço aérea; Aplicação: Entrada de serviço; Classe: Entrada de serviço - AMPLA; Tipo: Ancoragem em pontalete - Medição trifásica em parede - Demanda de 10 à 24KVA
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 125.000000; NumberOfPoles: 3
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Disjuntor

# IfcJunctionBox: Alvenaria - piso (9)
In: TERREO
Type - PredefinedType: POWER
Pset_Identificação_Elemento - Rede: Elétrica; Nome: 400x400x400 mm; Descrição: Caixa de passagem de embutir no piso; Aplicação: Caixa de passagem de fiação; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso
Name
CX14
CX15
CX16
CX17
CX18
CX19
CX20
CX21
CX22

# IfcJunctionBox: Aço pintada - piso (4)
In: COBERTURA
Type - PredefinedType: POWER
Pset_Identificação_Elemento - Rede: Elétrica; Nome: 400x400x150 mm; Descrição: Caixa de passagem de embutir no piso; Aplicação: Caixa de passagem de fiação; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - piso
Name
CX1
CX2
CX3
CX4

# IfcJunctionBox: Caixa de passagem aço pintada (13)
In: TERREO
Type - PredefinedType: POWER
Pset_Identificação_Elemento - Rede: Elétrica; Nome: 400x400x150mm; Descrição: Caixa de passagem de embutir no piso; Aplicação: Caixa de passagem de fiação; Classe: Acessórios p/ eletrodutos; Tipo: Caixa de passagem aço pintada
Name
CX1
CX10
CX11
CX12
CX13
CX23
CX24
CX3
CX4
CX5
CX7
CX8
CX9

# IfcJunctionBox: Interruptor (49)
In: TERREO
Type - PredefinedType: POWER
Pset_AltoQi_QiBuilder - Requer aterramento: Não; Posição: Média
Pset_Identificação_Elemento - Rede: Elétrica; Aplicação: Caixa; Classe: Dispositivo Elétrico - embutido; Tipo: Interruptor
Name | Tipo de ponto | Quantidade | Nome | Descrição
30 x  | Interruptor simples | 1 | simples - 1 tecla | Interruptor simples 1 tecla - 1,10m do piso
 | Interruptor simples | 3 | simples - 3 teclas | Interruptor simples 3 teclas - 1,10m do piso
14 x  | Interruptor simples | 2 | simples - 2 teclas | Interruptor simples 2 teclas - 1,10m do piso
4 x  | Interruptor paralelo | 1 | paralelo - 1 tecla | Interruptor paralelo 1 tecla - 1,10m do piso

# IfcJunctionBox: Tomada - uso específico (56)
Type - PredefinedType: POWER
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Tomada 2P+T; Quantidade: 1; Rendimento: 1
Pset_AltoQi_QiBuilder - Requer aterramento: Sim
Pset_Identificação_Elemento - Rede: Elétrica; Aplicação: Caixa; Classe: Dispositivo Elétrico - embutido; Tipo: Tomada - uso específico
Name | In | Potência (W) | Fator de potência | Posição | Nome | Descrição
11 x  | TERREO | 400 | 0.8 | Baixa | Desfibrilador | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
11 x  | TERREO | 150 | 0.8 | Média | Eletrocautério | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso
 | TERREO | 2000 | 0.8 | Baixa | Copiadora | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
5 x  | TERREO | 165 | 0.8 | Baixa | Microcomputador | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
2 x  | TERREO | 1000 | 0.8 | Baixa | Esterilizador | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
2 x  | TERREO | 800 | 0.8 | Baixa | Estufa | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
 | TERREO | 1500 | 0.8 | Média | Forno microondas | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,10m do piso
 | TERREO | 312 | 0.8 | Baixa | Geladeira duplex | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
 | TERREO | 185 | 0.8 | Média | Liquidificador | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso
2 x  | TERREO | 640 | 0.8 | Média | Sanduicheira | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso
3 x  | TERREO | 2500 | 1 | Alta | Chuveiro simples | Ponto 2P+T a 2,20m do piso
12 x  | COBERTURA | 1247 | 0.9 | Alta | Condicionador de ar Split 12000BTU | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso
3 x  | COBERTURA | 2110 | 0.9 | Alta | Condicionador de ar Split 18000BTU | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso
 | COBERTURA | 3160 | 0.9 | Alta | Condicionador de ar Split 30000BTU | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso

# IfcJunctionBox: Tomada hexagonal (NBR14136) (115)
In: TERREO
Type - PredefinedType: POWER
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Tomada 2P+T; Quantidade: 1; Potência (W): 100; Fator de potência: 0.9; Rendimento: 1
Pset_AltoQi_QiBuilder - Requer aterramento: Sim
Pset_Identificação_Elemento - Rede: Elétrica; Aplicação: Caixa; Classe: Dispositivo Elétrico - embutido; Tipo: Tomada hexagonal (NBR14136)
Name | Posição | Nome | Descrição
95 x  | Baixa | 2P+T 10 A - baixa | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso
20 x  | Média | 2P+T 10 A - média | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso

# IfcLightFixture: Luminárias sobrepor (Osram) (113)
In: TERREO
Type - PredefinedType: DIRECTIONSOURCE
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Lâmpada; Quantidade: 1; Tipo de luminária: A2 (Direta); Fluxo luminoso para tensão 12V: 0; Fator de potência: 0.9; Rendimento: 1
Pset_AltoQi_QiBuilder - Posição: Teto
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Pset_Identificação_Elemento - Rede: Elétrica; Aplicação: Caixa; Classe: Lâmpadas Led; Tipo: Luminárias sobrepor (Osram)
Name | Fluxo luminoso para tensão 127V = Fluxo luminoso para tensão 220V | Potência (W) | Nome | Descrição
24 x  | 2000 | 20 | Ledvance Linear 20W | Luminária LED 20W
61 x  | 3000 | 32 | Ledvance Livin 32W | Luminária LED 32W
28 x  | 4000 | 40 | Ledvance Panel 40W | Luminária LED 40W

# IfcLightFixture: Refletor (Aiha) (16)
In: TERREO
Type - PredefinedType: DIRECTIONSOURCE
Pset_AltoQi_QiBuilder-Ponto1 - Tipo de ponto: Lâmpada; Quantidade: 1; Tipo de luminária: A1 (Direta); Fluxo luminoso para tensão 12V: 0; Fluxo luminoso para tensão 127V: 2700; Fluxo luminoso para tensão 220V: 2700; Potência (W): 30; Fator de potência: 0.5; Rendimento: 1
Pset_AltoQi_QiBuilder - Posição: Piso
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Pset_Identificação_Elemento - Rede: Elétrica; Nome: 30W com sensor; Descrição: Refletor de led; Aplicação: Caixa; Classe: Lâmpadas Led; Tipo: Refletor (Aiha)
